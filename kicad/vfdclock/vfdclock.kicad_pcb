# Repository kanpapa/vfdclock-T3605

File README.md:

# vfdclock-T3605

時計専用IC(T3605)と蛍光表示管(VFD)のパーツセット用に作成した基板のKiCadデータです。

## 外観

Rev.1.0

## 3Dモデル

Rev.1.1

## 回路図

- [Rev.1.1 PDF](/docs/vfdclock_sch-rev11.pdf) 

## 補足情報

- 経緯は以下のサイトをご覧ください。
    - [VFD時計を製作してみました](https://kanpapa.com/today/2025/01/digit-vfd-clock.html)
- Rev.1.0の基板はミスがありましたので修正済のRev.1.1のデータに更新しています。ただしRev.1.1で基板を製作した実績はありません。

## 参考サイト

- [電気電子工作の部屋](https://cba.sakura.ne.jp/index.htm)

## 利用上の注意

本サイトに掲載している回路、技術などは無保証です。  
これらの利用によって発生したトラブルには責任を負いかねます。自己責任にてご利用ください。  
KiCADデータおよびガーバーデータはCC BY-NC-SA 4.0 (Copyright (C) 2025 Kazuhiro Ouchi)です。

## KiCad design kicad/vfdclock/vfdclock.kicad_pcb

Parts:
C1: 30P; C_Trim_D6.0mm_H5.0mm_P5.0mm
C2: 5P; C_Disc_D4.7mm_W2.5mm_P5.00mm
C3, C4: 100uF; CP_Radial_D4.0mm_P2.00mm
C5: 0.1uF; C_Disc_D3.0mm_W2.0mm_P2.50mm
D1: 1S4; D_A-405_P7.62mm_Horizontal
J1: DC12V; BarrelJack_Horizontal
R1: 150; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R2: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: CLR-SEC; SW_PUSH_6mm
SW2: UP-HOUR; SW_PUSH_6mm
SW3: UP-MIN; SW_PUSH_6mm
SW4, SW5: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: T3605; DIP-42_W15.24mm_LongPads
U2: VFD-48C
U3: MC7905; TO-220F-3_Vertical
Y2: 4.1943MHz; Crystal_C38-LF_D3.0mm_L8.0mm_Horizontal

Connections:
/a1: U1.26 (a1), U2.21 (a1)
/a2: U1.31 (a2), U2.26 (a2)
/a3: U1.33 (a3), U2.29 (a3)
/a4: U1.6 (d4), U1.36 (a4), U2.4 (a4)
/b1: U1.25 (b1), U2.20 (b1)
/b2: U1.28 (b2), U2.23 (b2)
/b3: U1.32 (b3), U2.28 (b3)
/b4: U1.35 (b4), U2.31 (b4)
/c1: U1.18 (c1), U2.16 (c1)
/c2: U1.14 (c2), U2.12 (c2)
/c3: U1.11 (c3), U2.9 (c3)
/c4: U1.7 (c4), U2.5 (c4)
/d1: U1.17 (d1), U2.15 (d1)
/d2: U1.29 (d2), U2.24 (d2)
/d3: U1.10 (d3), U2.8 (d3)
/e1: U1.16 (e1), U2.14 (e1)
/e2: U1.13 (e2), U2.11 (e2)
/e3: U1.9 (e3), U2.7 (e3)
/e4: U1.5 (e4), U2.3 (e4)
/f1: U1.27 (f1), U2.22 (f1)
/f2: U1.30 (f2), U2.25 (f2)
/f3: U1.34 (f3), U2.30 (f3)
/f4: U1.37 (f4), U2.32 (f4)
/g1: U1.15 (g1), U2.13 (g1)
/g2: U1.12 (g2), U2.10 (g2)
/g3: U1.8 (g3), U2.6 (g3)
/g4: U1.38 (g4), U2.33 (g4)
GND: C3.2, C5.2, SW1.2, SW2.2, SW3.2, U1.22 (GND), U1.42 (GND), U3.3 (VO)
unnamed: D1.1 (K), J1.2, J1.3
unnamed: SW4.2 (B), U1.3 (BLANK)
unnamed: R2.2, SW5.2 (B)
unnamed: R2.1, U1.4 (BLIGHT)
unnamed: SW1.1, U1.41 (CLR-SEC)
unnamed: SW2.1, U1.40 (UP-HOUR)
unnamed: SW3.1, U1.39 (UP-MIN)
unnamed: C2.1, U1.23 (XT), Y2.2
unnamed: C1.1, U1.24 (~XT), Y2.1
unnamed: R1.2, U2.1 (F2)
VCC: C1.2, C2.2, C3.1, C4.1, C5.1, J1.1, R1.1, SW4.1 (A), SW4.3 (C), SW5.3 (C), U1.21 (VCC), U2.17 (COM), U3.1 (GND)
VEE: C4.2, D1.2 (A), U2.18 (F1), U3.2 (VI)

Notes on the sheet:
VCC-VEE 12V VCC-GND 5V
SW4とSW5は連動。２段階の明るさ調節用

Board: 2 copper layers, 72.0 x 47.0 mm, 21 parts (0 on the bottom side), 40 nets.

Other parts of the board:
MH1, MH2, MH4: MountingHole_3.2mm_M3

## Commit log

2025-01-22 1st commit
2025-01-23 Update LICENSE
2025-01-23 Fixed bug
2025-01-23 Updated comments
2025-01-23 回路図のPDFへのリンクを追加
2025-01-24 Create LICENSE
